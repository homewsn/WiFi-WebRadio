# IAR project webradio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; FATAL_ERROR; NOTERM
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../src/; $CC3200SDK_DIR$/driverlib; $CC3200SDK_DIR$/inc; $CC3200SDK_DIR$/oslib; $CC3200SDK_DIR$/third_party/FreeRTOS/source; $CC3200SDK_DIR$/third_party/FreeRTOS/source/include; $CC3200SDK_DIR$/third_party/FreeRTOS/source/include/IAR/ARM_CM4; $CC3200SDK_DIR$/simplelink/include; $CC3200SDK_DIR$/simplelink_extlib/provisioninglib; $CC3200SDK_DIR$/netapps/http/server
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: webradio.bin
  ILINK.IlinkOutputFile: webradio.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: $CC3200SDK_DIR$/simplelink/ewarm/OS_debug/Exe/simplelink.a; $CC3200SDK_DIR$/driverlib/ewarm/Debug/Exe/driverlib.a; $CC3200SDK_DIR$/oslib/ewarm/free_rtos_debug/Exe/free_rtos.a; webserver.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Project
    ../src/: gpio_if.c hal-spi-vs1003.c main.c network_common.c pinmux.c ring_buf.c ring_buf_audio.c startup_ewarm.c uart_if.c vs1053-spi.c
