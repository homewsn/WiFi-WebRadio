# IAR project webradio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3235SF TexasInstruments CC3235SF
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DeviceFamily_CC3220; _FATAL_ERROR; _DEBUG_INT; _NOTERM
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: ../src; ../src/sysconfig; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/kernel/freertos; $SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source/ti/posix/iar; $FREERTOS_INSTALL_DIR$/FreeRTOS/Source/include; $FREERTOS_INSTALL_DIR$/FreeRTOS/Source/portable/IAR/ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: webradio.srec
  postbuild: ielftool --bin --verbose $TARGET_BPATH$.out $TARGET_BPATH$.bin
  ILINK.IlinkOutputFile: webradio.out
  ILINK.IlinkIcfFile: cc32xxsf_freertos.icf
  ILINK.IlinkExtraOptions: -L$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/source; --threaded_lib; -L$SIMPLELINK_CC32XX_SDK_INSTALL_DIR$/kernel; -f../src/sysconfig/ti_utils_build_linker.cmd.genlibs; ti/devices/cc32xx/driverlib/iar/Release/driverlib.a; --silent
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../image/: image.syscfg
  group Project
    ./: cc32xxsf_freertos.icf
    ../src/: hal-spi-vs1003.c main_freertos.c ring_buf.c ring_buf_audio.c uart_term.c vs1053-spi.c webradio.c webradio.syscfg
  group SysConfig Generated Files
    ../src/sysconfig/: FreeRTOSConfig.h syscfg_c.rov.xs ti_drivers_config.c ti_drivers_config.h ti_drivers_net_wifi_config.c ti_freertos_config.c ti_freertos_portable_config.c ti_net_config.c ti_utils_build_linker.cmd.genlibs
